## base_external/Config.in
```kconfig
source "$BR2_EXTERNAL_project_base_PATH/package/assignment-4-mpuscian/Config.in"
```
